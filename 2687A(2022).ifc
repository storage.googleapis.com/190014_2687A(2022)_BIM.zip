Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-05-18T13:25:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 18 13:25:16 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{7699CB77-82A3-438E-8281-1B00263F2F93}\ifc * Database version: 5507 * Database creation date: Wed May 18 13:25:15 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 18 13:25:16 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 18 13:25:16 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 2687A Cover part for shower faucet, 2687A(2022):2687A Cover part for shower faucet:435580
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions - NominalDepth: 87.5097 mm; NominalHeight: 173.031 mm; NominalWidth: 169.617 mm
Type - General - Author: BIMStone; BIMObjectName: 2687A(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins amd troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/05/2022
Type - Green Building Properties - EAN Number: 6414150099212; EN Standard: EN 817; ETIM Class Number: EC010546 Mechanical control system for shower; Noise Class: I (ISO 3822); UNSPSC Class Number: 30181810 Faucet trim; URL Declaration of Conformity: http://static.oras.com/DoC/2687A; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/2687A; Catalog Drawing URL: http://static.oras.com/catdrw/2687A; Dimension Drawing URL: http://static.oras.com/dimdrw/2687A; FDV Document URL: http://www.oras.com/datasheet/2687A/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/2687A; Group: Shower faucet; Interactive AR View URL: https://static.oras.com/AR/2687A; Item Type: Sales item; Manufacturer: Oras; Market: International;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/2687A; Model: 2687A Cover part for shower faucet; Name_en: 2687A Cover part for shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2687A; Product Family: Oras Optima; Product Image URL: http://static.oras.com/image/2687A; Product URL: http://static.oras.com/2687A; Technical DataSheet URL: http://www.oras.com/datasheet/2687A/en; Type Name: 2687A Cover part for shower faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Concealed Parts: Rosette plate frame;Round rosette;BLUECLICK for an easy, screwless trim plate installation;Fastening of the function unit with screws;Function unit; Flow Rate At 300kPa: 0.0116538 m3/s; Installation Type: Concealed wall mounting; Lever Handle: Single operating lever/handle;Pin shape;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Adjustable hot water stop (included, retrofittable); Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2687A(2022); Features: Trim Kit;Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2687A; Name: 2687A Cover part for shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 170x90x175 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2687A; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2687A Cover part for shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.059334 m2; Volume: 0.00256832 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2687A(2022): 2687A Cover part for shower faucet; Family and Type: 2687A(2022): 2687A Cover part for shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2687A(2022): 2687A Cover part for shower faucet; Type Id: 2687A(2022): 2687A Cover part for shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
